# Keil uVision project project.uvprojx, settings and files
target Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\RL-ARM\Driver;..\..\RL-ARM\Config;..\..\RL-ARM\RL-RTX\inc;..\..\User\libapp;..\..\User\bsp\inc;..\..\User\bsp;..\..\User;..\..\Libraries\STM32_USB_Device_Library\Class\dfu\inc;..\..\Libraries\STM32_USB_Device_Library\Core\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c header.h
    ../../RL-ARM/Config/: Net_Config.c Net_Debug.c
  group APP
    ../../User/libapp/: app_tcpnet_lib.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_it.c stm32f4xx_assert.c bsp_flash_if.c bsp_stm32f4flash.c
    ../../User/bsp/src/: bsp_key.c bsp_led.c bsp_timer.c bsp_uart_fifo.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_flash.c stm32f4xx_rtc.c misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_pwr.c
  group CMSIS
    ../../User/bsp/: system_stm32f4xx.c
  group RL-TCPnet/Lib
    ../../RL-ARM/RL-TCPnet/: TCPD_CM3.lib
  group RL-TCPnet/Driver
    ../../RL-ARM/Driver/: ETH_STM32F4xx.c ETH_STM32F4xx.h
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
software components: CMSIS:CORE 4.3.0
